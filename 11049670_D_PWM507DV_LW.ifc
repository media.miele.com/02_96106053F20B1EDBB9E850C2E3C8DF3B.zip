Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-07-14T09:48:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 14 09:48:31 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{7D9E3FFB-AD18-421E-B1DD-A89F7BD786A9}\ifc * Database version: 5507 * Database creation date: Wed Jul 14 09:48:29 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 14 09:48:30 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 14 09:48:30 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 51507251_D_11049670_PWM507DV_LW, 11049670_D_PWM507DV_LW:51507251_D_11049670_PWM507DV_LW:210127
In: Level 1
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Orange, z_Miele_Design_Powder Coat_Grey, z_Miele_Design_Glass, z_Miele_Design_Powder Coat_Lotus White, Polypropylene, z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Connection_Water_IN, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, Default
Pset_BuildingElementProxyCommon - Reference: 51507251_D_11049670_PWM507DV_LW
